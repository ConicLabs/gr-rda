<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_fifo_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>filter_coeff</value></param>
<param><key>value</key><value>[14614,-69849,-203468,-216117,-7860,194302,81889,-216542,-207219,195672,372287,-93615,-558778,-131378,743447,557343,-899809,-1447471,1004420,5224804,7347329,5224804,1004420,-1447471,-899809,557343,743447,-131378,-558778,-93615,372287,195672,-207219,-216542,81889,194302,-7860,-216117,-203468,-69849,14614]</value></param>
<param><key>label</key><value>FIR Filter Coefficients</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>label</key><value>Noise Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_points</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>920e6</value></param>
<param><key>label</key><value>RX Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>900e6</value></param>
<param><key>step</key><value>0.1e6</value></param>
<param><key>stop</key><value>1e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>31.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_uhd_device3_rda</key>
<param><key>id</key><value>variable_uhd_device3_rda_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>top_block</key><value>rfnoc_fifo_test.py</value></param>
<param><key>keyfile</key><value>/home/gnuradio/keyfile.conf</value></param>
<param><key>debug</key><value>0</value></param>
<param><key>use_gr_rda</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wave_amp</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>label</key><value>Wave Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wave_freq</value></param>
<param><key>value</key><value>samp_rate/1000</value></param>
<param><key>label</key><value>Wave Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>step</key><value>samp_rate/100</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise_amp</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>wave_amp</value></param>
<param><key>freq</key><value>wave_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value></value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0</value></param>
<param><key>alias</key><value>0</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>2</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0_0</value></param>
<param><key>alias</key><value>7654321</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>0</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0_0_0</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>1</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
