<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_fir_tx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>tx_tone</value></param>
<param><key>amp</key><value>tx_wave_amp</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>tx_noise_amp</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fir</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fir_0</value></param>
<param><key>taps</key><value>filter_coeff</value></param>
<param><key>block_index</key><value>0</value></param>
<param><key>device_index</key><value>-1</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>radio_index</key><value>1</value></param>
<param><key>direction</key><value>tx</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>stream_args</key><value></value></param>
<param><key>freq</key><value>1.982e9</value></param>
<param><key>rate</key><value>1e6</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>ant</key><value>"TX/RX"</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_noise_amp</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>0.9</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>920e6</value></param>
<param><key>start</key><value>900e6</value></param>
<param><key>stop</key><value>1e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>31</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_wave_amp</value></param>
<param><key>value</key><value>0.8</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>0.9</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_tone</value></param>
<param><key>value</key><value>samp_rate/16</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>samp_rate/100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>filter_coeff</value></param>
<param><key>label</key><value>FIR Filter Coefficients</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>value</key><value>[14614,-69849,-203468,-216117,-7860,194302,81889,-216542,-207219,195672,372287,-93615,-558778,-131378,743447,557343,-899809,-1447471,1004420,5224804,7347329,5224804,1004420,-1447471,-899809,557343,743447,-131378,-558778,-93615,372287,195672,-207219,-216542,81889,194302,-7860,-216117,-203468,-69849,14614]</value></param>
</block>
<block>
<key>variable_uhd_device3_rda</key>
<param><key>id</key><value>variable_uhd_device3_rda_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>top_block</key><value>rfnoc_fir_tx.py</value></param>
<param><key>use_gr_rda</key><value>1</value></param>
<param><key>keyfile</key><value>/home/rynmrlw/keyfile.conf</value></param>
<param><key>debug</key><value>0</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fir_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fir_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_radio_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
